# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay1ms.c Delay1ms.h key.c key.h I2C.h AT24C02.c AT24C02.h I2C.c Nixie.h Nixie.c key-hz.h key-hz.c key-duty.c key-duty.h UART.h UART.c
